# Keil uVision project keda_xx.uvprojx, settings and files
target keda (::::)
  device: CW32L031C8 WHXY
  pack: WHXY.CW32L031_DFP.1.0.4
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: keda_xx
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Core\Inc;..\Drivers\inc;..\myCode
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_cw32l031.s
  group Application/User/Core
    ../Core/src/: interrupts_cw32l031.c main.c tim.c uart.c adc.c gpio.c
  group Drivers/Core
    ../Drivers/src/: cw32l031_rcc.c cw32l031_systick.c cw32l031_uart.c cw32l031_adc.c cw32l031_flash.c cw32l031_gpio.c cw32l031_atim.c cw32l031_btim.c cw32l031_gtim.c
  group Drivers/CMSIS
    ../Drivers/src/: system_cw32l031.c
  group myCode
    ../myCode/: myMain.c
software components: CMSIS:CORE 5.6.0
